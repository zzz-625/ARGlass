# Keil uVision project ARGlass.uvprojx, settings and files
target ARGlass (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NANO120SD3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.2
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(42000000) CPUTYPE("Cortex-M0")
  output: ARGlass
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\fih\inc;..\Library\nuvoton\Device\Nuvoton\Nano100Series\Include;..\Library\nuvoton\StdDriver\inc;..\Library\nuvoton\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_nano100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/nuvoton/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../Library/nuvoton/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group Libraries
    ../Library/nuvoton/StdDriver/src/: clk.c gpio.c i2c.c retarget.c spi.c sys.c timer.c uart.c usbd.c fmc.c wdt.c
    ../Library/fih/src/: descriptors.c backlight.c Ecx335af.c hid_transfer.c imu_spi.c lt_i2c.c key.c LT7211_upgrade.c Ecx335af_calibration.c lp_i2c.c mcu_version.c i2c_alsps.c download_flag.c
  group User
    ../: main.c
