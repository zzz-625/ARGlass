# Keil uVision project LT7211Bfwupgrade.uvprojx, settings and files
target LT7211Bfwupgrade (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NANO120SD3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: LT7211Bfwupgrade
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\fih\inc;..\Library\nuvoton\Device\Nuvoton\Nano100Series\Include;..\Library\nuvoton\StdDriver\inc;..\Library\nuvoton\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../Library/nuvoton/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../Library/nuvoton/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group Libraries
    ../Library/nuvoton/StdDriver/src/: clk.c gpio.c retarget.c spi.c sys.c uart.c
    ../Library/fih/src/: Ecx335af.c lt_i2c.c LT7211_upgrade.c
  group User
    ../: main.c
software components: CMSIS:CORE 5.1.2
